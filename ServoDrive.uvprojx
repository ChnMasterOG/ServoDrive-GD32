# Keil uVision project ServoDrive.uvprojx, settings and files
target ServoDrive-fw (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F130F4 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.0
  cpu: IROM(0x08000000,0x04000) IRAM(0x20000000,0x01000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ServoDrive +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c include: .\Core\Inc;.\GD32F1x0_Firmware_Library\CMSIS\GD\GD32F1x0\Include;.\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Include;.\Utilities;..\ServoDrive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Core
    ./Core/Src/: main.c gpio.c gd32f1x0_it.c rcu.c adc.c tim.c motor.c flash.c i2c.c
    ./: systick.c
  group GD32F1x0_fw_lib/CMSIS
    ./GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group GD32F1x0_fw_lib/Peripheral
    ./GD32F1x0_Firmware_Library/GD32F1x0_standard_peripheral/Source/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_misc.c gd32f1x0_opa.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_slcd.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group Utilities
    ./Utilities/: gd32f130f_start.c
  group Startup
    ./GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
